<?xml version="1.0" encoding="iso-8859-1"?>
<!-- THIS IS A GENERATED FILE: PLEASE DO NOT EDIT -->

<workspace>
  <project>
    <path>$WS_DIR$\ZigbeeCoor.ewp</path>
  </project>
  <batchBuild/>
</workspace>
