# IAR project ZigbeeCoor.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NULL_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; EFR32MG1B; EFR32MG1B232F256GM32; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeCoor/ZigbeeCoor_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeCoor\ZigbeeCoor_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeCoor/ZigbeeCoor_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeCoor/ZigbeeCoor.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\util; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..; ..\..\..\submodules\Device\SiliconLabs\EFR32MG1B\Include; ..\..\..\submodules\CMSIS\Include; ..\..\..\submodules\emlib\inc; ..\..\..\submodules\emdrv\common\inc; ..\..\..\submodules\emdrv\rtcdrv\inc; ..\..\..\submodules\emdrv\sleep\inc; ..\..\..\submodules\emdrv\trace\inc; ..\..\..\submodules\emdrv\gpiointerrupt\inc; ..\..\..\submodules\emdrv\ecode; ..\..\..\submodules\emdrv\uartdrv\inc; ..\..\..\submodules\emdrv\spidrv\inc; ..\..\..\submodules\emdrv\dmadrv\inc; ..\..\..\submodules\emdrv\ustimer\inc; ..\..\..\submodules\emdrv\rtcdrv\inc; ..\..\..\submodules\kits\common\bsp\; ..\..\..\submodules\emdrv\gpiointerrupt\inc\; ..\..\..\submodules\emdrv\uartdrv\inc\; ..\..\..\submodules\emdrv\ustimer\inc\; ..\..\..\submodules\emdrv\rtcdrv\inc\; ..\..\..\submodules\emdrv\common\inc\; ..\..\..\hal\micro\cortexm3\efm32\config\; ..\..\..\submodules\emdrv\dmadrv\inc\; ..\..\..\submodules\emdrv\trace\inc\; ..\..\..\submodules\emdrv\tempdrv\inc; ..\..\..\hal\micro\cortexm3\efm32\efr32; ..\..\..\hal\micro\cortexm3\efm32; ..\..\..\submodules\efrseq\rfprotocol\ieee802154\cortex; ..\..\..\submodules\efrseq\common\cortex; ..\..\..\submodules\s029_efr4fpga_drv\inc; ..\..\..\submodules\reptile\glib; ..\..\..\submodules\reptile\glib\glib; ..\..\..\submodules\kits\LumiBoard\config; ..\..\..\submodules\kits\common; ..\..\..\submodules\kits\LumiBoard\config\Com
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; EFR32MG1B; EFR32MG1B232F256GM32; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ZigbeeCoor/ZigbeeCoor_endpoint_config.h"; BOARD_HEADER="app\builder\ZigbeeCoor\ZigbeeCoor_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ZigbeeCoor/ZigbeeCoor_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ZigbeeCoor/ZigbeeCoor.h"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\util; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..; ..\..\..\submodules\kits\LumiBoard\config; ..\..\..\submodules\kits\common; ..\..\..\submodules\kits\LumiBoard\config\Com
  OBJCOPY.OOCOutputFile: ZigbeeCoor.hex
  postbuild: ZigbeeCoor.bat $TARGET_BPATH$ \..\..\..
  ILINK.IlinkOutputFile: ZigbeeCoor.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\efm32\efr32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group _lib
    ../../../hal/micro/cortexm3/efm32/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c ext-device.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token-def.c token.c
    ../../framework/plugin/address-table/: address-table-cli.c address-table.c
    ../../framework/util/: af-event.c af-main-common.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../hal/micro/generic/: antenna-stub.c crc.c endian.c mem-util.c random.c sim-eeprom.c
    ./: call-command-handler.c cli.c stack-handler-stub.c
    ../../util/serial/: com.c command-interpreter2.c ember-printf.c serial.c
    ../../framework/plugin/concentrator/: concentrator-support-cli.c concentrator-support.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../hal/: ember-configuration.c
    ../../framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../framework/plugin/heartbeat/: heartbeat.c
    ../../framework/plugin/identify/: identify-cli.c identify.c
    ../../framework/plugin/identify-feedback/: identify-feedback.c
    ../../framework/plugin-soc/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    ../../framework/plugin/network-find/: network-find.c
    ../../framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../util/security/: security-address-cache.c
    ../../framework/plugin/simple-main/: simple-main.c
    ../../framework/plugin/simple-metering-client/: simple-metering-client-cli.c simple-metering-client.c
    ../../util/: source-route-common.c source-route.c
    ../../framework/plugin/time-server/: time-server.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group _lib/emdrv
    ../../../submodules/emdrv/dmadrv/src/: dmadrv.c
    ../../../submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../submodules/emdrv/sleep/src/: sleep.c
    ../../../submodules/emdrv/tempdrv/src/: tempdrv.c
    ../../../submodules/emdrv/trace/src/: trace.c
    ../../../submodules/emdrv/uartdrv/src/: uartdrv.c
    ../../../submodules/emdrv/ustimer/src/: ustimer.c
  group _lib/emlib
    ../../../submodules/emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../submodules/Device/SiliconLabs/EFR32MG1B/Source/: system_efr32mg1b.c
  group _lib/Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-efr32mg1b-efr32/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-efr32mg1b-efr32/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1b-efr32/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1b-efr32/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1b-efr32/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1b-efr32/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1b-efr32/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-efr32mg1b-efr32/: cbke-stub-library.a
    ../../../build/debug-basic-library-cortexm3-iar-efr32mg1b-efr32/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-efr32mg1b-efr32/: debug-extended-stub-library.a
    ../../../build/end-device-bind-library-cortexm3-iar-efr32mg1b-efr32/: end-device-bind-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1b-efr32/: enhanced-beacon-request-stub-library.a
    ../../../build/gp-stub-library-cortexm3-iar-efr32mg1b-efr32/: gp-stub-library.a
    ../../../build/hal-library-cortexm3-iar-efr32mg1b-efr32/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-efr32mg1b-efr32/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-efr32mg1b-efr32/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-efr32mg1b-efr32/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1b-efr32/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-efr32mg1b-efr32/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-efr32mg1b-efr32/: security-library-link-keys-stub.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-efr32mg1b-efr32/: sim-eeprom1-library.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-efr32mg1b-efr32/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-efr32mg1b-efr32/: zll-stub-library.a
  group App/Config
    ../../framework/util/: config.h
    ./: ZigbeeCoor.h ZigbeeCoor_board.h ZigbeeCoor_endpoint_config.h ZigbeeCoor_tokens.h
  group App/HC-Uart
    ./: Uart_CmdEnum.c Uart_CmdEnum.h Uart_CmdExec.c Uart_CmdExec.h Uart_Receiver.c Uart_Receiver.h Uart_Transmitter.c Uart_Transmitter.h
  group App/Main/Af_main
    ../../framework/util/: af-main-soc.c
  group App/Main/Callback
    ./: callback-stub.c ZigbeeCoor_callbacks.c
  group App/Zigbee
    ./: ZigbeeEvent.c ZigbeeEvent.h
  group Driver/Board/Common/bsp
    ../../../submodules/kits/common/bsp/: bsp.h bsp_bcc.c bsp_bcp.h bsp_stk.c bsp_stk_leds.c
  group Driver/Board/Common/driver
    ../../../submodules/kits/common/drivers/: udelay.c udelay.h
  group Driver/Board/LumiBoard
    ../../../submodules/kits/LumiBoard/config/: bspconfig.h fl216flash_config.h
  group Driver/Com
    ../../../submodules/kits/LumiBoard/config/Com/: macro.c macro.h typedefs.h
  group Driver/Delay
    ./: halDelay.c halDelay.h
  group Driver/ID-Type
    ./: attribute-id.h attribute-type.h
  group Midware/EventData
    ./: EventDataBuffer.c EventDataBuffer.h
